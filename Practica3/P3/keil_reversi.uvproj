# Keil uVision project keil_reversi.uvproj, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC2105 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x1FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: keil_reversi
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group Startup Code
    ./: Startup.s
  group System Calls
    ./: Retarget.c
  group Source Code
    ./: cola.c sudoku_2021.c timer.c celda.h cola.h sudoku_2021.h tableros.h Gestor_Alarmas.h Gestor_Alarmas.c Gestor_Pulsacion.c pulsacion.c GPIO.c GPIO.h evento.h Gestor_Pulsacion.h pulsacion.h Gestor_IO.h Gestor_IO.c pw_id_control.c pw_id_control.h timer.h main.c planificador.c planificador.h cuadricula.h RTC.h RTC.c WT.c WT.h SWI.s Gestor_Interrupciones.h Gestor_Interrupciones.c UART0.h UART0.c Gestor_Serial.h Gestor_Serial.c
